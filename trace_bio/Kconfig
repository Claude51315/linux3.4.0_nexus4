## trace_bio/Kconfig
```kconfig
config TRACEBIO
    bool "Custom Trace utility"
    default y
    help
    add instrument code to trace IO behavior
```
